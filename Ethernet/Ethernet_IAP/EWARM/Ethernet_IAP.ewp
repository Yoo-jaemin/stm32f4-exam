# IAR project Ethernet_IAP.ewp, settings and files
configuration Ethernet_IAP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include\netif; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include\netif\ppp; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include\lwip; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include\lwip\apps; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\LWIP\Target; ../Core/Inc; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\LWIP\App; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Drivers\CMSIS\Core\Include; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Drivers\STM32F4xx_HAL_Driver\Inc; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Drivers\CMSIS\Core\Include; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Drivers\CMSIS\Device\ST\STM32F4xx\Include; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\system\arch; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include\lwip\prot; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include\lwip\priv; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src\include\lwip\apps; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\src; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Middlewares\Third_Party\LwIP\system; D:\2_Projects\Exam\CubeMx\Ethernet\Ethernet_IAP\Drivers\BSP\Components\lan8742; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ethernet_IAP.hex
  ILINK.IlinkOutputFile: Ethernet_IAP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: tcp_echoserver.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
