<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project_i2c_e2pr.ewp</path>
  </project>
  <batchBuild />
</workspace>
