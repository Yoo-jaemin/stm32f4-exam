# IAR project SD_BootLoader_MX.ewp, settings and files
configuration GTD_5100FN_BootLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: Base; Drivers\CMSIS\Include; Drivers\CMSIS\Device\ST\STM32F4xx\Include; Drivers\STM32F4xx_HAL_Driver\Inc; Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; App\SD; App/Interface/Industrial_Standard/PoE; Drivers\FSMC; Drivers\GPIO; Drivers\LCD; Drivers\LCD\LCD_Driver; Drivers\SD; Drivers\TIMER; Drivers\Component; Middlewares\FatFs; Middlewares\FatFs\src; Middlewares\FatFs\src\option; Middlewares\GDI; Middlewares\GDI\Color; Middlewares\GDI\Fonts; Middlewares\Lwip\src\include; Middlewares\Lwip\system; Drivers\USART; App\Flash; App\Task; App\IO_Ctrl; App\Display; App\Sensor_Upload
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GTD-5100FN_BIOS_REV.bin
  ILINK.IlinkOutputFile: SD_BootLoader_MX.out
  ILINK.IlinkIcfFile: Base\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Display
    App/Display/: Display.c Display.h
  group App/Flash
    App/Flash/: Flash.c Flash.h
  group App/IO_Ctrl
    App/IO_Ctrl/: IO_Ctrl.c IO_Ctrl.h
  group App/SD
    App/SD/: SD_Card.c SD_Card.h
  group App/Sensor_Upload
    App/Sensor_Upload/: CRC.c CRC.h Sensor_Upload.c Sensor_Upload.h
  group App/Task
    App/Task/: Task.c Task.h
  group Base
    Base/: app_ethernet.c app_ethernet.h common.h ethernetif.c ethernetif.h flash_if.c flash_if.h lwipopts.h main.c main.h startup_stm32f407xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h tftp.c tftp_client.h tftp_common.h tftp_example.c tftp_example.h tftp_opts.h tftpserver.c tftpserver.h udpClientRAW.c udpClientRAW.h udpServerRAW.c udpServerRAW.h
  group Drivers/CMSIS
    Base/: system_stm32f4xx.c
  group Drivers/Components
    Drivers/Component/: dp83848.c
  group Drivers/FSMC
    Drivers/FSMC/: fsmc.c fsmc.h
  group Drivers/GPIO
    Drivers/GPIO/: gpio.c gpio.h
  group Drivers/LCD
    Drivers/LCD/: lcd.c lcd.h
  group Drivers/LCD/LCD_Driver
    Drivers/LCD/LCD_Driver/: ili9225g.c ili9225g.h
  group Drivers/SD
    Drivers/SD/: bsp_driver_sd.c bsp_driver_sd.h sd_diskio.c sd_diskio.h
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Drivers/USART
    Drivers/USART/: usart.c usart.h
  group Middlewares/FatFs
    Middlewares/FatFs/src/: diskio.c diskio.h fatfs.c fatfs.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf.h ffconf_template.h integer.h
  group Middlewares/GDI
    Middlewares/GDI/: gdi.c gdi.h
  group Middlewares/GDI/Fonts
    Middlewares/GDI/Fonts/: fimg07x12.h font07x12.h font07x28.h font11x16.h font29x48.h font32x53.h fonts.c fonts.h
  group Middlewares/Lwip/Api
    Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Lwip/Core
    Middlewares/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Lwip/Core/IPv4
    Middlewares/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Lwip/Netif
    Middlewares/LwIP/src/netif/: ethernet.c
