# IAR project LED_blinking.ewp, settings and files
configuration LED_blinking (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: D:\2_Projects\Exam\CubeMx\LED_blingking\LED_blinking\Drivers\STM32F4xx_HAL_Driver; D:\2_Projects\Exam\CubeMx\LED_blingking\LED_blinking\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; D:\2_Projects\Exam\CubeMx\LED_blingking\LED_blinking\Drivers\CMSIS\Include; D:\2_Projects\Exam\CubeMx\LED_blingking\LED_blinking\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED_blinking.bin
  ILINK.IlinkOutputFile: LED_blinking.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
